# IAR project Li-Fi project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: bitwise_operation.h main.c tm4c123gh6pm.h
  group ADC
    ADC/: adc.c adc.h
  group Li-Fi
    Li-Fi/: Laser.c Laser.h
  group Sensors/Fume-Sensor
    Sensors/Fume-Sensor/: fume_sensor.c fume_sensor.h
  group Sensors/Magnetic-Sensor
    Sensors/Magnetic-Sensor/: magnetic-sensor.c magnetic-sensor.h
  group Sensors/Ultrasonic-Sensor
    Sensors/Ultrasonic-Sensor/: ultrasonic-sensor.c ultrasonic-sensor.h
  group Timer
    Timer/: Timer0A.c Timer0A.h
